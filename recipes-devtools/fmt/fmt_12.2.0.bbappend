FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Turn-libfmt-c-into-a-shared-library.patch"
